# Keil uVision project ARM_Programs.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: ARM7 (Big Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM7TDMI) EBIG
  output: ARM_Programs
  c flags: Optim=1
  group Source Group 1
    ./how_to_divide_two_numbers/: how_to_divide_two_numbers.asm
